<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/dmm_154sensor_sm_remote_display_app_2_4g_LP_CC2652R7_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>