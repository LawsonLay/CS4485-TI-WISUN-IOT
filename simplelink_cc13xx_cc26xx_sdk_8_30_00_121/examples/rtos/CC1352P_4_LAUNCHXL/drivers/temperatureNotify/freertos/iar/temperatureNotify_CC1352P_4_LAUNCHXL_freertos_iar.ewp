# IAR project temperatureNotify_CC1352P_4_LAUNCHXL_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: temperatureNotify_CC1352P_4_LAUNCHXL_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
