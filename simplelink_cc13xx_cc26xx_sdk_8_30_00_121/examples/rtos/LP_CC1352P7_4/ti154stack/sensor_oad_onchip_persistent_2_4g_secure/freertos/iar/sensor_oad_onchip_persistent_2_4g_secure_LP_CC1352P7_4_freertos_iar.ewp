# IAR project sensor_oad_onchip_persistent_2_4g_secure_LP_CC1352P7_4_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: sensor_oad_onchip_persistent_2_4g_secure_LP_CC1352P7_4_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
