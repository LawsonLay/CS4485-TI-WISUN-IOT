# IAR project dmm_154collector_sm_remote_display_app_2_4g_LP_EM_CC1354P10_1_tirtos7_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: dmm_154collector_sm_remote_display_app_2_4g_LP_EM_CC1354P10_1_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
