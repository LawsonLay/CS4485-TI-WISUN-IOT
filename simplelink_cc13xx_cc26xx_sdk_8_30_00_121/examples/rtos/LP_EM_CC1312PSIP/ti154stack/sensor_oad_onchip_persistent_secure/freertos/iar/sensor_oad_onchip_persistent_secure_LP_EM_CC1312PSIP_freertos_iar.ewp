# IAR project sensor_oad_onchip_persistent_secure_LP_EM_CC1312PSIP_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: sensor_oad_onchip_persistent_secure_LP_EM_CC1312PSIP_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
