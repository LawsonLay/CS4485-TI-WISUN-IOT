<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sensor_oad_offchip_2_4g_secure_LP_CC1352P7_1_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>