# IAR project collector_sm_LP_EM_CC2674P10_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: collector_sm_LP_EM_CC2674P10_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
