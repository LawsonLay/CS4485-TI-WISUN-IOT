<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sensor_oad_onchip_persistent_secure_CC26X2R1_LAUNCHXL_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>