<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sensor_oad_onchip_secure_LP_CC1312R7_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>