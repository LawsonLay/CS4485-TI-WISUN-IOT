# IAR project dmm_154collector_remote_display_oad_app_2_4g_CC1352P_4_LAUNCHXL_tirtos7_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: dmm_154collector_remote_display_oad_app_2_4g_CC1352P_4_LAUNCHXL_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
