# IAR project ns_node_src_LP_EM_CC1312PSIP_tirtos7_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
configuration SecureBoot (ARM)
  as the first configuration, except:
  ILINK.IlinkExtraOptions: --config_def SBL_ENABLE=1
  group (top)
    ./: ns_node_src_LP_EM_CC1312PSIP_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
