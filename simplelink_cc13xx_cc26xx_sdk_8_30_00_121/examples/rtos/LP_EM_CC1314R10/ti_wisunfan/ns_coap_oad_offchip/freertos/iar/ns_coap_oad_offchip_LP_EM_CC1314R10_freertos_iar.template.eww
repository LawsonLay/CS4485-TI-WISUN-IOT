<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/ns_coap_oad_offchip_LP_EM_CC1314R10_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>