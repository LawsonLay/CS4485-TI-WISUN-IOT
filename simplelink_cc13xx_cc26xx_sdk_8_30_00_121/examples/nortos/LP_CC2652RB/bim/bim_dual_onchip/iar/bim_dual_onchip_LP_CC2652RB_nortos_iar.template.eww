<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/bim_dual_onchip_LP_CC2652RB_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>