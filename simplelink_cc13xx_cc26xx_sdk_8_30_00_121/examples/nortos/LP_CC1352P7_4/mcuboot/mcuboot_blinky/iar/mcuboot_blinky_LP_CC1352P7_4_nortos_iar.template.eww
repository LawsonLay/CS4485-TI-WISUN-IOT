<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/mcuboot_blinky_LP_CC1352P7_4_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>