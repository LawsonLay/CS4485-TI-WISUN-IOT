<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sensor_oad_onchip_persistent_secure_CC1352R1_LAUNCHXL_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>