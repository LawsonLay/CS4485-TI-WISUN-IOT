# IAR project mcuboot_blinky_LP_EM_CC1354P10_6_nortos_iar.ewp, settings and files
configuration TZ_Disabled (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkExtraOptions: --config_def DUAL_SLOT=0
configuration TZ_Enabled (ARM)
  as the first configuration, except:
  ILINK.IlinkExtraOptions: --config_def DUAL_SLOT=1
  group (top)
    ./: mcuboot_blinky_LP_EM_CC1354P10_6_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
