# IAR project mcuboot_blinky_LP_CC1352P7_1_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: mcuboot_blinky_LP_CC1352P7_1_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
