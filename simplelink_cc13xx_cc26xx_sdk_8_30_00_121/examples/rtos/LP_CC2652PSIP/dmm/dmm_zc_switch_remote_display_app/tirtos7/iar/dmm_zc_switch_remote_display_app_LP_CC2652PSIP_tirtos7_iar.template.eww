<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/dmm_zc_switch_remote_display_app_LP_CC2652PSIP_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>