# IAR project ns_coap_node_src_LP_EM_CC1354P10_6_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
configuration SecureBoot (ARM)
  as the first configuration, except:
  ILINK.IlinkExtraOptions: --config_def SBL_ENABLE=1
  group (top)
    ./: ns_coap_node_src_LP_EM_CC1354P10_6_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
